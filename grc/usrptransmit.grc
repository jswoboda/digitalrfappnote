<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrpdrftransmit</value></param>
<param><key>author</key><value>MIT Haystack</value></param>
<param><key>description</key><value>Transmit a sngle channel from a USRP sink from Digital RF.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>USRP Transmit</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>2.414e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>gr_digital_rf_digital_rf_channel_source</key>
<param><key>id</key><value>gr_digital_rf_digital_rf_channel_source_0</value></param>
<param><key>dir</key><value>~/DATA/drfappnote/transexp0</value></param>
<param><key>end</key><value></value></param>
<param><key>gapless</key><value>True</value></param>
<param><key>min_chunksize</key><value>0</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>hide_msg_port</key><value>True</value></param>
<param><key>start</key><value>"now"</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>gr_digital_rf_digital_rf_channel_source_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
